# IAR project UMVHV2.ewp, settings and files
configuration UMVHV2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030K6 ST STM32F030K6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=25000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; HSI_VALUE=8000000; LSI_VALUE=40000; VDD_VALUE=3300; PREFETCH_ENABLE=1; INSTRUCTION_CACHE_ENABLE=0; DATA_CACHE_ENABLE=0; STM32F030x6
  ICCARM.CCIncludePath2: ../Core/Inc; ../Core/Src; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UMVHV2_pre.hex
  ILINK.IlinkOutputFile: UMVHV2.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$/config/linker/ST/stm32f030x6.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f030x6.s
  group Application/User/Core
    ../Core/Src/: main.c mbcrc.c stm32f0xx_it.c
    ../Core/Inc/: mbcrc.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_dma.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_usart.c stm32f0xx_ll_utils.c
